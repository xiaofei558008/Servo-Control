# IAR project ServoV0.1.ewp, settings and files
configuration ServoV0.1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RC ST STM32F303RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: ServoV0.1.out
  ILINK.IlinkIcfFile: stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers
    ./: 
  group Drivers/STM32F3xx_HAL_Driver
    ./: 
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_uart_ex.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_tim.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_comp.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash.c stm32f3xx_hal_opamp.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dac.c stm32f3xx_hal_spi.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_wwdg.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pwr.c stm32f3xx_hal_can.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_adc.c
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Middlewares
    ./: 
  group Middlewares/USB_Device_Library
    ./: 
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application
    ./: 
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xc.s
  group Application/User
    ./: 
    ../Src/: usbd_conf.c usb_device.c main.c stm32f3xx_it.c usbd_desc.c usbd_cdc_if.c stm32f3xx_hal_msp.c
